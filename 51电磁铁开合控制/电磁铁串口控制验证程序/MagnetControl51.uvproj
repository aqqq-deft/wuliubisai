# Keil uVision project MagnetControl51.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODAT2
  output: MagnetControl51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: main.c magnet.c uart.c
