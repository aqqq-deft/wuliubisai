# Keil uVision project motion.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: motion +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源代码组 1
    ./: main.c
