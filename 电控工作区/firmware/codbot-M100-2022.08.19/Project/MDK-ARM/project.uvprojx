# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,EMPL_TARGET_STM32F4,MPU9250,EMPL,MPL_LOG_NDEBUG=1
  c include: ..\..\Libraries\STM32F1xx_HAL_Driver\Inc;..\..\Libraries\CMSIS\Include;..\..\User\app\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\..\SEGGER\RTT;..\..\DMP\driver\include;..\..\DMP\driver\eMPL\inv_mpu;..\..\DMP\driver\eMPL\inv_mpu_dmp_motion_driver;..\..\DMP\driver\include;..\..\DMP\driver\stm32L;..\..\DMP\mllite;..\..\DMP\mpl;..\..\DMP\eMPL-hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../User/app/src/: main.c tool.c pid.c motor.c steercontrol.c autocontrol.c feedback.c bucket_control.c
  group BSP
    ../../User/bsp/src/: bsp.c bsp_led.c bsp_key.c bsp_dwt.c bsp_uart.c bsp_timer.c bsp_servo.c bsp_ps2.c mpuiic.c mpu9250.c bsp_encoder.c bsp_motor.c bsp_adc.c bsp_oled.c bsp_can.c
    ../../User/bsp/: stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_hal_conf.h
  group DMP
    ../../DMP/driver/eMPL/inv_mpu/: inv_mpu.c
    ../../DMP/driver/eMPL/inv_mpu_dmp_motion_driver/: inv_mpu_dmp_motion_driver.c
    ../../DMP/driver/stm32L/: log_stm32.c
    ../../DMP/eMPL-hal/: eMPL_outputs.c
    ../../DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../../DMP/mpl/: libmpllib.lib
  group MDK-ARM
    ../../User/: startup_stm32f103xe.s
  group HAL_Driver
    ../../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_sram.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER
    ../../SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.2.3, Compiler:Event Recorder 1.2.1, Compiler:I/O:STDOUT 1.2.1, Device:Startup 1.0.0
