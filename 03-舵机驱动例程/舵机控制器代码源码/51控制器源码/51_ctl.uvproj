# Keil uVision project 51_ctl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51_duoji +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group src
    ./src/: delay.c global.c io.c main.c ps2.c pwm.c timer.c uart.c w25q64.c spi.c adc.c
