/******************************************************************************************************                  
串口控制
    改程序将舵机执行封装为指令：如#0P2000T1000!形式。
    0表示舵机序号，即0号舵机；
    2000表示pwm1为2000（范围500~2500）；
    1000表示0号舵机要从原来位置执行到目标位置需要花费1000ms。
    比如，我想要2号舵机，用500ms的时间，执行到1300这个位置。
    命令为：#2P1300T500!
    舵机的周期0.5ms-2.5ms。
    0.5对应0度，2.5对应180度。比如达到90度，则舵机周期为1.5ms，pwm1值对应为1500。  
关键：
    1、机械臂舵机的控制原理
    2、舵机执行时间的处理
    3、串口对命令的解析

        
********************************************************************************************/
//#include <MsTimer2.h>             //定时器库的 头文件
#include <Servo.h>               //声明舵机库
#include <SoftwareSerial.h>    //包含软串口头文件，硬串口通信文件库系统自带   String uart1_receive_buf = "";
String uart1_receive_buf = "";   //声明一个字符串数组
char cmd_return[101];
/*******************************一些宏定义****************************************/
#define DJ_NUM  6                //宏定义伺服舵机的个数  
Servo myservo[DJ_NUM];           //创建舵机伺服对象数组
SoftwareSerial mySerial(A4,A5); //创建一个软串口的类，模拟引脚4,5分别代表 RX, TX引脚


#define beep_on() {digitalWrite(BEEP_PIN, LOW);}
#define beep_off() {digitalWrite(BEEP_PIN, HIGH);} 
/**********宏定义区**********/

#define  NLED_MS_BETWEEN        1000
#define  WARNING_MS_BETWEEN     1000
#define  WARNING_VOLTAGE_VALUE  6
#define  DUOJI_MS_BETWEEN       20
#define  BEEP_PIN   12             //定义蜂鸣器引脚D12
#define  NLED_PIN   13             //定义呼吸灯引脚D13
                      //PS2手柄右摇杆Y轴数据
int temp;
bool detach_flag = 0;
byte type = 0;
unsigned int delay_ms =1500;
unsigned int time_max = 0;
unsigned int duoji_index, i;       //声明舵机变量 （舵机号）
byte duoji_pin[DJ_NUM] = {10, A2, A3, A0, A1, 7};//定义一个数组，存储引脚数字
/***********************************结构体变量声明*******************************************/
typedef struct {//舵机结构体变量声明
    unsigned int aim = 1500;   //舵机目标值 
    float cur = 1500;          //舵机当前值
    unsigned  int time1 = 1500;//舵机执行时间
    float inc= 0.00;          //舵机值增量，以20ms为周期
}duoji_t;


static unsigned long last_time = 0;
duoji_t duoji_doing[DJ_NUM];           //用结构体变量声明一个舵机变量数组
byte duoji_doing_flag[DJ_NUM] = {0}; 
void handle_nled();
void handle_duoji();              //声明舵机处理函数
void handle_uart1();              //声明串口处理函数

void handle_auto_group(void);     
 
void setup() {
    pinMode(BEEP_PIN, OUTPUT);
    pinMode(NLED_PIN, OUTPUT);
    digitalWrite(BEEP_PIN, HIGH );
    Serial.begin(115200); 


    
    for(byte i = 0; i < DJ_NUM; i++) {//循环使相应的舵机伺服对象连接到对应的引脚
        myservo[i].attach(duoji_pin[i]);
       // myservo[1].detach(); 
    }
    for(byte i = 0; i < DJ_NUM; i++) {
        myservo[i].writeMicroseconds( duoji_doing[i].aim);//循环写入初始pwm1目标值 
    }

    for(byte i = 0; i < DJ_NUM; i++) {//循环使相应的舵机伺服对象连接到对应的引脚
        myservo[i].detach();
        duoji_doing_flag[i] = 1;
    }

    mySerial.begin(9600);         //设置软串口波特率
    mySerial.println("SoftSerial Init OK");
}

void loop() {
    handle_nled();  //信号灯处理
    handle_uart1(); //串口1 处理
    handle_duoji(); //舵机处理
}






